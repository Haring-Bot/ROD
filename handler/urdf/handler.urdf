Commit message: progress second robot

File: handler/urdf/handler.urdf (robot description, URDF)
Before this commit: robot handler, 7 links, 6 joints
Links:
- added link world
Joints:
- added joint world_fixed: type fixed, parent world, child base_link, origin xyz=0 0 0.1 rpy=0 0 0
